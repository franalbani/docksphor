options:
  parameters:
    author: Fran Albani
    generate_options: qt_gui
    id: docksphor
    output_language: python
    title: Docksphor
  states: {}

blocks:
- name: address
  id: variable
  parameters:
    value: '''tcp://127.0.0.1:35000'''
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1'
  states: {}
- name: fosphor_qt_sink_c_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: '0'
    freq_span: samp_rate
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: address
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {}

connections:
- [zeromq_sub_source_0, '0', fosphor_qt_sink_c_0, '0']

metadata:
  file_format: 1
